# Keil uVision project BaiTL1.1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BaiTL1.1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BaiTL1.1.c
target target 2 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BaiTL1.1 +hex
  c flags: Optimize=8 SizeSpeed=1
target target 3 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BaiTL1.1 +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 4 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BaiTL1.1 +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 5 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BaiTL1.1 +hex
  c flags: Optimize=8 SizeSpeed=1
target Target 6 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BaiTL1.1 +hex
  c flags: Optimize=8 SizeSpeed=1
